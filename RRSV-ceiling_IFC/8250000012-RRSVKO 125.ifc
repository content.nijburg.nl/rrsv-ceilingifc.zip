Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 6b1eb16f-a2b5-4f14-b6b2-d6b3dafa441d, NumberOfSaves: 37]
File name: Project Number
Time: 2024-05-17T11:08:02+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (ENU) - IFC 23.3.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort, OutPort_2227395_1
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: NLRS_57_AIR_UN_ceiling-diffuser-rrsv_LT_sacs:125, NLRS_57_AIR_UN_ceiling-diffuser-rrsv_LT_sacs:125:2227395
In: Default
Type - Description: Return grill with valve for use in ceiling or wall, Type RRSVMO and RRSVKO; PredefinedType: DIFFUSER; Material: RAL9010
Type - Other - Category: Air Terminals; Family Name: NLRS_57_AIR_UN_ceiling-diffuser-rrsv_LT_sacs; SACS_Base_Index: 3
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NLRS_M_c01_diameter: 125 mm
Type - General - SACS_Article_Data: RRSV_Data; SACS_Factors: RRSV_Factors; SACS_Revised_by: J. Feeke; SACS_Revision_Date: 17-05-2024; SACS_Revision_Number: 3.21.04
Type - Identity Data - Assembly Code: 57.00; Description: Return grill with valve for use in ceiling or wall, Type RRSVMO and RRSVKO; Manufacturer: Solid Air Climate Solutions; Model: RRSVMO/RRSVKO; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 17-05-2024; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 3.21.04; NLRS_C_description: Return grill with valve for use in ceiling or wall, Type RRSVMO and RRSVKO; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles; Product: RRSV; Type Name: 125; URL: https://solid-air.nl/producten/roosters/plafondroosters/ventielen/rrsv
Type - Mechanical - Flow - Max Flow: 40 dm3/s; Min Flow: 20 dm3/s
Type - Visibility - SACS_Show_Arrows: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Classification: 57.00 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: 125; sets with these values: 2
Other - Family: NLRS_57_AIR_UN_ceiling-diffuser-rrsv_LT_sacs; Family and Type: NLRS_57_AIR_UN_ceiling-diffuser-rrsv_LT_sacs: 125; Type: 125; Type Id: 2227326
Model Properties - Conus max setting: 9; Conus min setting: -17; Conus Setting: 6; SACS_Color_Ral: yes; SACS_Mounting_Ring: no; SACS_Option_1: RRSVKO; SACS_Standard_Color: yes
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 0.025143 m2; Size: 125ø; Volume: 0.000181011 m3
Identity Data - Mark: 8683; NLRS_C_materiaal_kleur: RAL 9010; NLRS_C_model: RRSVKO 125; SACS_Article_Code: 8250000012; SACS_Gross_Cost: 16; SACS_Price_Date: 24-04-2024
Materials and Finishes - SACS_Color: RAL 9010; SACS_Face_Color: RAL9010
Mechanical - NLRS_M_c01_drukverlies_statisch: 0 Pa; SACS_Max_Lp_dBA: 28; SACS_Max_Ploss: 35 Pa; System Classification: Return Air
Mechanical - Flow - Flow: 0 dm3/s; NLRS_M_c01_debiet: 0 dm3/s; SACS_Lp_dBA: 0
Phasing - Phase Created: New Construction
Visibility - SACS_Warning_Disable: no
