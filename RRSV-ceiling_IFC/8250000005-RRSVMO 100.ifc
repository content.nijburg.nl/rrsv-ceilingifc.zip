Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 6b1eb16f-a2b5-4f14-b6b2-d6b3dafa441d, NumberOfSaves: 37]
File name: Project Number
Time: 2024-05-17T11:08:05+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (ENU) - IFC 23.3.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort, OutPort_2227399_1
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: NLRS_57_AIR_UN_ceiling-diffuser-rrsv_LT_sacs:100, NLRS_57_AIR_UN_ceiling-diffuser-rrsv_LT_sacs:100:2227399
In: Default
Type - Description: Return grill with valve for use in ceiling or wall, Type RRSVMO and RRSVKO; PredefinedType: DIFFUSER; Material: RAL9010, Sendzimir verzinkt
Type - Other - Category: Air Terminals; Family Name: NLRS_57_AIR_UN_ceiling-diffuser-rrsv_LT_sacs; SACS_Base_Index: 2
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NLRS_M_c01_diameter: 100 mm
Type - General - SACS_Article_Data: RRSV_Data; SACS_Factors: RRSV_Factors; SACS_Revised_by: J. Feeke; SACS_Revision_Date: 17-05-2024; SACS_Revision_Number: 3.21.04
Type - Identity Data - Assembly Code: 57.00; Description: Return grill with valve for use in ceiling or wall, Type RRSVMO and RRSVKO; Manufacturer: Solid Air Climate Solutions; Model: RRSVMO/RRSVKO; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 17-05-2024; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 3.21.04; NLRS_C_description: Return grill with valve for use in ceiling or wall, Type RRSVMO and RRSVKO; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles; Product: RRSV; Type Name: 100; URL: https://solid-air.nl/producten/roosters/plafondroosters/ventielen/rrsv
Type - Mechanical - Flow - Max Flow: 35 dm3/s; Min Flow: 15 dm3/s
Type - Visibility - SACS_Show_Arrows: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Classification: 57.00 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: 100; sets with these values: 2
Other - Family: NLRS_57_AIR_UN_ceiling-diffuser-rrsv_LT_sacs; Family and Type: NLRS_57_AIR_UN_ceiling-diffuser-rrsv_LT_sacs: 100; Type: 100; Type Id: 2227324
Model Properties - Conus max setting: 10; Conus min setting: -10; Conus Setting: 9; SACS_Color_Ral: yes; SACS_Mounting_Ring: yes; SACS_Option_1: RRSVMO; SACS_Standard_Color: yes
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 0.0201106 m2; Size: 100ø; Volume: 0.0000197637 m3
Identity Data - Mark: 8687; NLRS_C_materiaal_kleur: RAL 9010; NLRS_C_model: RRSVMO 100; SACS_Article_Code: 8250000005; SACS_Gross_Cost: 10; SACS_Price_Date: 24-04-2024
Materials and Finishes - SACS_Color: RAL 9010; SACS_Face_Color: RAL9010
Mechanical - NLRS_M_c01_drukverlies_statisch: 0 Pa; SACS_Max_Lp_dBA: 28; SACS_Max_Ploss: 35 Pa; System Classification: Return Air
Mechanical - Flow - Flow: 0 dm3/s; NLRS_M_c01_debiet: 0 dm3/s; SACS_Lp_dBA: 0
Phasing - Phase Created: New Construction
Visibility - SACS_Warning_Disable: no
